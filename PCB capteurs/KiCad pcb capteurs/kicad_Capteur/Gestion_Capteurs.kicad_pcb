# Repository thomasvernoux/Projet5ArobotInfirmier

File README.md:

This is my 5th year pschool roject. A robot able to move and do some measurments using sensors. 
STM32, Python, C, FPGA

## KiCad design PCB capteurs/KiCad pcb capteurs/kicad_Capteur/Gestion_Capteurs.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad_Reserve-10mm
J1: Screw_Terminal_01x02; TerminalBlock_Phoenix_MKDS-1,5-2-3.81_1x02_P3.81mm_Horizont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
J2: Molex Picoblade 53398; Molex_PicoBlade_53398-0671_1x06-1MP_P1.25mm_Vertical
J3: Connecteur HE10; he10-10d_LowProfile
LG1: LOGO_CPE_Ver2021; Logo_CPE-10-2021_14X6mm
TP1: TestPoint; SolderWirePad_GND_Connection_1-35mmDrill
TP2: TestPoint; SolderWirePad_Test-Point_1mmDrill
U1: STM32L010R8T6; LQFP-64_10x10mm_P0.5mm

Connections:
+3V3: J2.6
/+5V: J1.1, TP2.1
/DB_NRST: J2.5, U1.7 (NRST)
/DB_SWCLK: J2.3, U1.49 (PA14-SWCLK)
/DB_SWDIO: J2.1, U1.46 (PA13-SWDIO)
GND: J1.2, J2.2, J2.4, TP1.1

Notes on the sheet:
Connexion Masse Sonde Référence 0V
Penser à: -Placer des points de test sur les tensions de sortie des alimentations -Protéger l'entrée d'alimentation contre les inversions de polarité
Sous-ensemble à concevoir: - Selon votre design...
Eléments d'entrée: - Alimentation 5V 500mA - Selon votre design.... Elements de sortie - Selon votre design....
Source Alimentation 5V 500mA
Trous de Fixation D:3mm
Connecteur Prise Programmation
Connecteur Signaux auxiliaires Dont Capteur mesure de courant Autres signaux éventuels

Board: 2 copper layers, 11 parts (0 on the bottom side), 5 nets, no tracks yet.

## Commit log

2021-09-24 V1.0 par Thomas
    Quelques tests
2021-09-24 V1.1
2021-09-24 V1.3
2021-09-24 V1.4
    ajout des documents de layouni
2021-09-24 V1.5
    ajout de l'alim thomas (simulation V1)
2021-09-30 V1-Paul
    ltspice moteur brushless
2021-09-30 v test
2021-09-30 v
    spice alim
2021-10-01 v buck ok
2021-10-07 v
    il faur que le servo 2 ailles dans l'autre sens
2021-10-08 v
    spice capteur de frequence cardiaque
2021-10-08 v
    spice
2021-10-10 v
    test ihm tkinter
2021-10-11 v
    tests uart ok en emission
2021-10-12 v
    tests serial mais ca ne marche pas trop
2021-10-13 v
    debug
2021-10-13 tests urart mais ne marche qu'en reception ...
2021-10-14 v pcb capteurs
2021-10-14 v1 uart reception
    l'UART marche ne reception pour la premiere fois !!!
2021-10-14 v reception uart
    l'uart marche en reception non bloquante (interruption)
2021-10-14 controle pwm du moteur du lidar
2021-10-14 v
    je n'arrive pas a faire marcher correctement les ports GPIOA ...
2021-10-17 v les 2 uart de la disco marchent mais le lidar ne repond pas
2021-11-18 création d'un nouveau projet m0, synchronisation avec le kicad
2021-12-03 led clignotte ok
2021-12-03 ok
    interruption uart ok, la led clignotte
2021-12-10 2021_12_10
    uart du lidar a debugger, marche presque
2021-12-14 pwm lidar ok
2021-12-14 pb usart lidar, spi ok mais pas testé
2021-12-16 v uart pc fonctionnelle et testée
2021-12-16 v traitement de l'info recu avec switch case
2022-01-03 v
    test
2022-01-03 suppression de tout les warnings
2022-01-05 reception lidar ok,filmé ok
2022-01-05 ihm non fonctionnelel
2022-01-05 ihm ok et decodage du bytearray ok
2022-01-06 reception des trames lidar ok
2022-01-06 lidar ok avec recuperation de la distance et de l'angle
2022-01-07 v lidar ok c'est fou !!!
2022-01-13 v spi completee avec des nouvelles fonctions
2022-01-14 v svg 14_01
2022-01-14 v ihm a complrter
2022-01-14 v avant mise a jour octets lidar
2022-01-14 v maj IHM pa
2022-01-15 v pc fixe
2022-01-15 v pc portable
2022-01-15 v rien
2022-01-17 v marche pas
2022-01-17 v ok presentation
2022-01-18 v rampe vitesse
2022-01-19 v ok rampe moteur
2022-01-19 v moteur pas trop top
2022-01-20 v ok
